# Keil uVision project CAN_Demo.uvprojx, settings and files
target CAN_Demo (6240000::V6.24::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CAN_Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User_alg;../User_chariot;../User_drv;../User_dvc;../User_ita;../User_tsk;../Middlewares/ST/ARM/DSP/Inc;../Middlewares/ST/ARM/DSP/Lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
  group User_alg
    ../User_alg/: alg_pid.cpp alg_slope.cpp kalman_filter.cpp alg_fsm.cpp alg_fsm.h
  group User_chariot
    ../User_chariot/: crt_chassis.cpp crt_lift.cpp
  group User_drv
    ../User_drv/: drv_math.cpp drv_tim.cpp drv_config.h drv_uart.cpp drv_can.cpp
  group User_dvc
    ../User_dvc/: dvc_motor_dji.cpp dvc_cybergear.cpp dvc_motor_mi.cpp dvc_dr16.cpp
  group User_ita
    ../User_ita/: ita_robot.cpp
  group User_tsk
    ../User_tsk/: tsk_config_and_callback.cpp config.h
software components: CMSIS:CORE 6.2.0
